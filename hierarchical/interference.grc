options:
  parameters:
    author: alysemjones
    generate_options: qt_gui
    id: interference
    output_language: python
    title: Interference
  states: {}

blocks:
- name: cent_freq_list
  id: variable
  parameters:
    value: np.linspace(-wide_samp_rate/2+signal_samp_rate/2, wide_samp_rate/2-signal_samp_rate/2, num_channels)
  states: {}
- name: int_freq
  id: variable
  parameters:
    value: cent_freq_list[3]
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '8'
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: wide_samp_rate/num_channels
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 8e6/8
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: int_freq
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_psk_mod_0_0
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.001'
    mod_code: '"gray"'
    samples_per_symbol: num_channels*4
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: int_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: int_freq
    type: message
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: int_stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: int_stream
  states: {}

connections:
- [analog_random_source_x_0_0, '0', digital_psk_mod_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', virtual_sink_0, '0']
- [digital_psk_mod_0_0, '0', blocks_multiply_xx_1, '0']
- [pad_source_0, out, analog_sig_source_x_0_0_0, cmd]
- [virtual_source_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.6.0-rc1
