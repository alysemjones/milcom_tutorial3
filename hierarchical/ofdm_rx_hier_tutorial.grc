options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    category: '[RL OFDM DSA]'
    generate_options: hb
    id: ofdm_rx_hier_tutorial
    output_language: python
    run_options: run
    title: Burst OFDM Receiver Hierarchical
  states: {}

blocks:
- name: all_carriers
  id: variable
  parameters:
    value: '[*range(-int(fft_len/2)+ceil(num_guard/2),0),*range(1,int(fft_len/2)-floor(num_guard/2))]'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carrier_set, pilot_carrier_set, pilot_symbol_set)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm([occupied_carriers], n_syms=num_header_symbs, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_len_bits
  id: variable
  parameters:
    value: num_header_symbs*num_occupied
  states: {}
- name: header_mod
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: num_guard
  id: variable
  parameters:
    value: '11'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_occupied
  id: variable
  parameters:
    value: len(occupied_carriers)
  states: {}
- name: num_payload_symbs
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_pilots
  id: variable
  parameters:
    value: len(pilot_carriers)
  states: {}
- name: occupied_carrier_set
  id: variable
  parameters:
    value: ((occupied_carriers), (occupied_carriers),(occupied_carriers),(occupied_carriers),(occupied_carriers),(occupied_carriers),(occupied_carriers),(occupied_carriers),)
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: '[ x for x in all_carriers if x not in set(pilot_carriers)]'
  states: {}
- name: ofdm_symbol_duration
  id: variable
  parameters:
    value: (1/((1/(fft_len+cp_len))*(signal_samp_rate)))
  states: {}
- name: packet_len_bytes
  id: variable
  parameters:
    value: int(num_payload_symbs*(num_occupied*log2(len(payload_mod.points())))/8)
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carrier_set, pilot_carrier_set, pilot_symbol_set, num_header_symbs)
  states: {}
- name: payload_mod
  id: variable_constellation
  parameters:
    const_points: '[(-1-1j)/sqrt(2), ( -1+1j)/sqrt(2), (1+1j)/sqrt(2), (1-1j)/sqrt(2)]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: pilot_carrier_set
  id: variable
  parameters:
    value: ((pilot_carriers),(pilot_carriers),(pilot_carriers),(pilot_carriers),(pilot_carriers),(pilot_carriers),(pilot_carriers),(pilot_carriers),)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: (-21, -7, 7, 21)
  states: {}
- name: pilot_symbol_set
  id: variable
  parameters:
    value: ((pilot_symbols),(pilot_symbols),(pilot_symbols),(pilot_symbols),(pilot_symbols),(pilot_symbols),(pilot_symbols),(pilot_symbols),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: '[1] * num_pilots'
  states: {}
- name: sc_spacing
  id: variable
  parameters:
    value: signal_samp_rate/fft_len
  states: {}
- name: sync_word_0
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, 0, -1.4142135623730951, 0, -1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, -1.4142135623730951, 0, -1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, -1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, -1.4142135623730951, 0, -1.4142135623730951, 0, -1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, -1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, 1.4142135623730951, 0, -1.4142135623730951, 0, 1.4142135623730951, 0, -1.4142135623730951, 0, 0, 0, 0, 0, 0]'
  states: {}
- name: sync_word_1
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, 1, -1, -1, -1, -1, 1, -1, 1, 1, -1, 1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, 0, -1, 1, -1, 1, -1, 1, -1, -1, 1, 1, -1, -1, 1, -1, -1, -1, -1, 1, 1, 1, -1, 1, -1, -1, 1, 1, 0, 0, 0, 0, 0]'
  states: {}
- name: timing
  id: variable
  parameters:
    value: '"rx_time"'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: cent_freq
    offset: '0'
    phase: '0.0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+cp_len
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: cent_freq
  id: parameter
  parameters:
    value: 0e6
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: cp_len
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: '"frame_len"'
    output_symbols: 'True'
    samp_rate: int(signal_samp_rate)
    special_tags: ()
    timing_tag_key: '""'
    trigger_tag_key: '"packet_len"'
    type: complex
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '0'
    n_data_symbols: num_header_symbs
    sync_symbol1: sync_word_0
    sync_symbol2: sync_word_1
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: cp_len
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: frame_len
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: cp_len
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_0
  id: digital_ofdm_serializer_vcc
  parameters:
    fft_len: fft_len
    len_tag_key: frame_len
    occupied_carriers: occupied_carrier_set
  states: {}
- name: digital_ofdm_serializer_vcc_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carrier_set
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    threshold: threshold
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import log2
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from math import ceil
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: from math import floor
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_samp_rate/2
    gain: '1'
    interp: '1'
    samp_rate: wide_samp_rate
    type: interp_fir_filter_ccf
    width: 0.25*signal_samp_rate/2
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: wide_samp_rate/signal_samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: rx_bits_out
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: packet_data
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: rx_in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: cent_freq
    optional: 'True'
    type: message
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '2048'
    type: complex
  states: {state: disabled}
- name: signal_samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 125e3
  states: {}
- name: threshold
  id: parameter
  parameters:
    value: '0.96'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sig_samps
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: header_symbs
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: payload_symbs
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: header_samps
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: payload_samps
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: header_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: header_samps
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: header_symbs
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: payload_symbs
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: payload_samps
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: header_data
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: sig_samps
  states: {}
- name: wide_samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 125e3
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_crc32_bb_0, '0', pad_sink_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_2, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_3, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_0, '0', digital_ofdm_serializer_vcc_0_0, '0']
- [digital_ofdm_serializer_vcc_0, '0', virtual_sink_1, '0']
- [digital_ofdm_serializer_vcc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_serializer_vcc_0_0, '0', virtual_sink_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, virtual_sink_4, '0']
- [fft_vxx_1, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1_0, '0', digital_ofdm_frame_equalizer_vcvc_0_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', virtual_sink_0, '0']
- [pad_source_0_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_1, out, analog_sig_source_x_0, cmd]
- [virtual_source_0, '0', fft_vxx_1, '0']
- [virtual_source_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_0_2, '0', fft_vxx_1_0, '0']
- [virtual_source_1, '0', digital_header_payload_demux_0, header_data]
- [virtual_source_1, '0', pad_sink_1, in]
- [virtual_source_2, '0', blocks_delay_0, '0']
- [virtual_source_2, '0', digital_ofdm_sync_sc_cfb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
