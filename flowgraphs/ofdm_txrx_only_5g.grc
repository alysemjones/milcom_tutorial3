options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_only
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: back_pad
  id: variable
  parameters:
    value: '500'
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: '500'
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(wide_samp_rate/(signal_samp_rate))*time_steps)
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '11'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: 68*14
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 960e3
  states: {}
- name: snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,(1/32)-0.01,0.01,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: signal_samp_rate*16
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_volt
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../data/rx_bits.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../data/tx_bits.dat
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: head_size
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: wide_samp_rate
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: wide_samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_rx_hier_5g_0
  id: ofdm_rx_hier_5g
  parameters:
    cent_freq: '0'
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: ofdm_tx_hier_5g_0
  id: ofdm_tx_hier_5g
  parameters:
    back_pad: '500'
    cent_freq: cent_freq
    front_pad: front_pad
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,1,1,1
    name: '"OFDM Burst"'
    size: int(head_size/time_steps)
    srate: wide_samp_rate
    type: complex
    ymax: '64'
    ymin: '-64'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_tag_gate_0, '0']
- [blocks_add_xx_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_head_0, '0', blocks_throttle_0, '0']
- [blocks_tag_gate_0, '0', ofdm_rx_hier_5g_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [ofdm_rx_hier_5g_0, '0', blocks_file_sink_0, '0']
- [ofdm_rx_hier_5g_0, '0', blocks_null_sink_0, '0']
- [ofdm_tx_hier_5g_0, '0', blocks_head_0, '0']
- [ofdm_tx_hier_5g_0, '1', blocks_file_sink_0_0, '0']
- [ofdm_tx_hier_5g_0, '1', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.6.0-rc1
