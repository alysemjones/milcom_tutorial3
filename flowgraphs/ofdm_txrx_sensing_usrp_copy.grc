options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_only
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '64'
  states: {}
- name: back_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: cent_freq_list[3]+freq_usrp
  states: {}
- name: cent_freq_list
  id: variable
  parameters:
    value: np.linspace(-wide_samp_rate/2+signal_samp_rate/2, wide_samp_rate/2-signal_samp_rate/2, num_channels)
  states: {}
- name: cent_freq_rx
  id: variable
  parameters:
    value: '-cent_freq_list[3]+freq_usrp'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: freq_fosphor
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_usrp
  id: variable
  parameters:
    value: 2.35e9
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(signal_samp_rate/(signal_samp_rate))*time_steps)
  states: {}
- name: linear_gain
  id: variable
  parameters:
    value: '3.5'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '8'
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: num_data_symbs*80+num_header_symbs*80
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: num_zeros
  id: variable
  parameters:
    value: '100'
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '43'
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,(1/32)-0.01,0.01,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '47'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 8*signal_samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_volt
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: cent_freq-freq_usrp
    offset: '0'
    phase: '0.0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: cent_freq_list[6]
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: cent_freq_list[1]
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../data/rx_bits.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../data/tx_bits.dat
    type: byte
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: head_size
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: linear_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/fft_len
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: burst_start
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: wide_samp_rate
    type: complex
  states: {state: disabled}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.001'
    mod_code: '"gray"'
    samples_per_symbol: num_channels*4
  states: {state: disabled}
- name: digital_psk_mod_0_0
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.001'
    mod_code: '"gray"'
    samples_per_symbol: num_channels*4
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,num_channels=8,wide_samp_rate=2e6, cent_freqs=[]):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Freq Control',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_channels = num_channels
              self.wide_samp_rate = wide_samp_rate
              self.cent_freqs = cent_freqs
              self.samp_rate = int(self.wide_samp_rate/(1e6))
              self.msg_port_name_txrx = 'cent_freq'
              self.msg_port_name_sensor = 'narrow_cent_freq'
              self.msg_input_sensing = 'sensing_results'
              self.msg_input_packet = 'packet_results'
              self.message_port_register_out(pmt.intern(self.msg_port_name_txrx))
              self.message_port_register_out(pmt.intern(self.msg_port_name_sensor))
              self.message_port_register_in(pmt.intern(self.msg_input_sensing))
              self.set_msg_handler(pmt.intern(self.msg_input_sensing), self.handle_msg_sensing)
              self.message_port_register_in(pmt.intern(self.msg_input_packet))
              self.set_msg_handler(pmt.intern(self.msg_input_packet), self.handle_msg_packet)
              #self.cent_freqs = np.arange(-int((self.samp_rate/2)+(self.samp_rate/(self.num_channels*2))),int((self.samp_rate/2)+(self.samp_rate/(self.num_channels*2))),self.samp_rate/self.num_channels)
              #self.cent_freqs = self.cent_freqs[1:]
              self.position = 1
              self.count_sensor = 0
              self.count_packet = 0
              self.counter = 0
              self.count = 1
              self.packet = False
              self.packet_flag = False
              self.sensor_flag = False
          
          def handle_msg_sensing(self, msg): 
          	self.channels = pmt.to_python(msg)
          	self.channels = [0 if i < 0.4 else 1 for i in self.channels]
          	self.count_sensor += 1
          	self.sensor_flag = True
          	#if self.count_sensor < 100:
          	#   self.change_frequency()
          	   #print(self.count_sensor, self.counter, self.packet)
          	#if self.sensor_flag == True and self.packet_flag == True:
          	#	self.check_synch()
          	#print(self.channels, self.packet)
          	
          	#self.change_frequency()

          def handle_msg_packet(self, msg):
          	packetVal = pmt.to_python(msg)
          	self.counter += 1
          	if packetVal == False:
          		self.packet = False
          	else:
          		self.packet = True
          		self.count_packet += 1
          	self.packet_flag = True
          	if self.counter < 100:
          	    self.change_frequency()
          	#    PMT_msg_send =  pmt.dict_add(pmt.make_dict(), pmt.intern("transmit"), pmt.to_pmt('Send Frame'))
          	#    self.message_port_pub(pmt.intern(self.msg_port_name_send), PMT_msg_send)
          	    #zmq_socket_packet.send(pmt.serialize_str(pmt.to_pmt('Send Frame')))
          	   
          	#if self.sensor_flag == True and self.packet_flag == True:
          	#       self.check_synch()
          
          def check_synch(self):
              #self.change_frequency()
              print('synch: ' + str(self.count))
              print(self.count_packet, self.counter, self.packet)
              print(self.count_sensor, self.position, self.channels)
              self.count += 1
              self.packet_flag = False
              self.sensor_flag = False
          
          def change_frequency(self):
              cent_freq = self.cent_freqs[self.position]
              '''
              self.position += 1
              if self.position == len(self.cent_freqs):
                 self.position = 0
              self.count += 1
              '''
              PMT_msg_txrx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_double(cent_freq))
              self.message_port_pub(pmt.intern(self.msg_port_name_txrx), PMT_msg_txrx)
              PMT_msg_sensor =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(cent_freq-2.35e9))
              self.message_port_pub(pmt.intern(self.msg_port_name_sensor), PMT_msg_sensor)
          def work(self, input_items, output_items):
              return len(input_items[0])
    cent_freqs: '[i+freq_usrp for i in cent_freq_list]'
    num_channels: num_channels
    wide_samp_rate: wide_samp_rate
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    N: N
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import math

      class blk(gr.sync_block):
          def __init__(self, num_chans=8, N=64):
              gr.sync_block.__init__(
                  self,
                  name='PSD Sensing',
                  in_sig=[(np.float32,N)],
                  out_sig=None
              )
              self.num_chans = num_chans
              self.N = N
                     
              self.total_samps = 0
              self.total_epochs = 0  
              self.start_flag = 0
              self.fft_count = 0
                      
              self.portName = 'energy_vec'
              self.message_port_register_out(pmt.intern(self.portName))    
             
              self.energy_vect = np.zeros(self.num_chans)
              
          def work(self, input_items, output_items):
              total_items = input_items[0].shape[0] * input_items[0].shape[1]
              self.total_samps += total_items
              tagTuple = self.get_tags_in_window(0, 0, input_items[0].shape[0])

              tags_found = []
              if not len(tagTuple) == 0:       
                  for tag in tagTuple: 
                      if not pmt.to_python(tag.key) == 'packet_len':
                         tag_vect_num = int(input_items[0].shape[0] - ((self.total_samps - tag.offset*self.N)/self.N))
                         tags_found.append([pmt.to_python(tag.key), tag_vect_num])
                      
              for k in range(input_items[0].shape[0]):
                  if not len(tags_found) == 0:        
                      if tags_found[0][1] == k and tags_found[0][0] == 'burst_start':                              
                          self.fft_count = 0
                          self.start_flag = 1
                          self.total_epochs += 1
                          self.energy_vect = np.zeros(self.num_chans)
                          tags_found.pop(0)

                  if self.start_flag == 1:
                      chan_vals = input_items[0][k].reshape((self.num_chans, int(self.N/self.num_chans)))
                      self.fft_count += 1
                      for kk in range(self.num_chans):
                          self.energy_vect[kk] += np.mean(chan_vals[kk])
                              
                  if not len(tags_found) == 0:
                      if tags_found[0][1] == k and tags_found[0][0] == 'burst_end':                                
                          self.start_flag = 0                
                          #print('Finished Epoch #', self.total_epochs, ', FFTs Calculated: ', self.fft_count)
                          self.message_port_pub(pmt.intern(self.portName), pmt.to_pmt(self.energy_vect/self.fft_count))
                          tags_found.pop(0)                     
                                      
              return len(input_items[0])                    
    num_chans: num_channels
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq_fosphor
    freq_span: signal_samp_rate
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_samp_rate/2
    gain: '1'
    interp: '1'
    samp_rate: wide_samp_rate
    type: interp_fir_filter_ccf
    width: 0.25*signal_samp_rate/2
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: signal_samp_rate/wide_samp_rate
    type: complex
  states: {state: disabled}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_rx_hier_usrp_0
  id: ofdm_rx_hier_usrp
  parameters:
    signal_samp_rate: signal_samp_rate
  states: {}
- name: ofdm_tx_hier_usrp_0
  id: ofdm_tx_hier_usrp
  parameters:
    back_pad: back_pad
    front_pad: front_pad
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: signal_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int((front_pad+back_pad+num_samps)*(wide_samp_rate/(signal_samp_rate)))
    srate: wide_samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int((front_pad+back_pad+num_samps)*(wide_samp_rate/(signal_samp_rate)))
    srate: wide_samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: cent_freq_list[0]+freq_usrp
    dev_addr: addr=192.168.2.4
    gain0: tx_gain
    samp_rate: signal_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: cent_freq_list[0]+freq_usrp
    dev_addr: addr=192.168.1.4
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: signal_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sensing_stream
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sensing_stream
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx_out
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_psk_mod_0, '0']
- [analog_random_source_x_0_0, '0', digital_psk_mod_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_2, '0']
- [blocks_head_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_multiply_const_vxx_0, '0', ofdm_rx_hier_usrp_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_head_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0_0, '2']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [digital_psk_mod_0, '0', blocks_multiply_xx_0_0, '0']
- [digital_psk_mod_0_0, '0', blocks_multiply_xx_1, '0']
- [epy_block_0_0, cent_freq, ofdm_tx_hier_usrp_0, pdu_send]
- [epy_block_0_0, cent_freq, uhd_usrp_sink_0, command]
- [epy_block_0_0, cent_freq, uhd_usrp_source_0, command]
- [epy_block_0_0, narrow_cent_freq, analog_sig_source_x_0, cmd]
- [epy_block_2, energy_vec, epy_block_0_0, sensing_results]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0, '0']
- [ofdm_rx_hier_usrp_0, '0', blocks_file_sink_0, '0']
- [ofdm_rx_hier_usrp_0, packet_data, epy_block_0_0, packet_results]
- [ofdm_tx_hier_usrp_0, '0', blocks_multiply_const_vxx_1, '0']
- [ofdm_tx_hier_usrp_0, '1', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', blocks_tagged_stream_align_0, '0']
- [virtual_source_0_0, '0', mmse_resampler_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.6.0-rc1
