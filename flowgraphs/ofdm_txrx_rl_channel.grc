options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_rl
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: back_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: block_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+80+800)*(wide_samp_rate/(1e6))/num_channels)
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: 64e6
  states: {}
- name: channel_map
  id: variable
  parameters:
    value: '[int(num_channels/2) + i*1 if i < int(num_channels/2) else -int(num_channels/2)+i*1 for i in range(num_channels)]'
  states: {}
- name: fd
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(wide_samp_rate/(signal_samp_rate))*time_steps)
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '8'
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: num_data_symbs*80+num_header_symbs*80
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: num_zeros
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 16*1e6
  states: {}
- name: snr
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,(1/32)-0.01,0.01,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: 100*101
  states: {}
- name: velocity
  id: variable
  parameters:
    value: '100'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: (3*10^8)/cent_freq
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 16*32e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: 0e6
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: 0e6
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_channels
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: head_size
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: fd
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: num_channels
    type: complex
  states: {bus_sink: true}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: wide_samp_rate
    type: complex
  states: {}
- name: channels_channel_model2_0
  id: channels_channel_model2
  parameters:
    epsilon: '1.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '1'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    fDTs: fd/wide_samp_rate
    seed: '0'
  states: {state: disabled}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0,0.1,1.3)
    fDTs: 10.0/signal_samp_rate
    mags: (1,0.99,0.97)
    ntaps: '8'
    seed: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport pmt\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport random\nimport itertools\nimport copy\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self,log_file=None,num_channels=8,wide_samp_rate=20,time_steps=100,velocity=1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Freq Control',   # will show up in GRC\n            in_sig=None,\n            out_sig =None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.log_file = log_file\n        self.num_channels = num_channels\n        self.wide_samp_rate = wide_samp_rate\n        self.time_steps = time_steps\n        self.velocity = velocity\n        self.msg_port_name_tx = 'tx_cent_freq'\n        self.msg_port_name_rx = 'rx_cent_freq'\n        self.msg_port_name_int = 'int_cent_freq'\n        self.msg_port_name_int2 = 'int2_cent_freq'\n        self.msg_port_name_fd = 'doppler'\n        self.msg_input_sensing = 'sensing_results'\n        self.msg_input_packet = 'packet_results'\n        self.message_port_register_out(pmt.intern(self.msg_port_name_rx))\n        self.message_port_register_out(pmt.intern(self.msg_port_name_tx))\n        self.message_port_register_out(pmt.intern(self.msg_port_name_int))\n        self.message_port_register_out(pmt.intern(self.msg_port_name_int2))\n        self.message_port_register_out(pmt.intern(self.msg_port_name_fd))\n        self.message_port_register_in(pmt.intern(self.msg_input_sensing))\n        self.set_msg_handler(pmt.intern(self.msg_input_sensing), self.handle_msg_sensing)\n        self.message_port_register_in(pmt.intern(self.msg_input_packet))\n        self.set_msg_handler(pmt.intern(self.msg_input_packet), self.handle_msg_packet)\n        self.cent_freqs = np.arange(-int(self.wide_samp_rate/2),int(self.wide_samp_rate/2),self.wide_samp_rate/self.num_channels)\n        self.cent_freqs = self.cent_freqs[1:]\n        print(self.cent_freqs)\n        self.position = 0\n        self.packet = False\n        self.channels = []\n        self.state = False\n        self.count = 0\n        self.total = 0\n        self.flag = False\n        self.flag_packet = False\n        self.flag_sensing = False\n        self.cent_freq = 0e6\n        self.counter = 0\n        self.counter_2 = 0\n        ### RL Stuff ### \n        self.min_epsilon = 0.001\n        self.max_epsilon = 1\n        self.decay_rate = 0.1\n        self.alpha = 0.25\n        self.gamma = 0.9\n        self.values = [0,1]\n        self.num_values = len(self.values)\n        self.time_window = 1\n        self.num_actions = self.num_channels-1\n        self.num_states = self.num_values**(self.num_actions*self.time_window)\n        self.epsilon = 0\n        #self.num_states = 1\n        '''\n        self.order = 3\n        self.num_basis_functions = (self.order + 1)**(self.num_states)\n        self.c = np.array(list(itertools.product(range(self.order+1),repeat=self.num_states)), dtype=np.int32)\n        '''\n        self.policy = np.zeros(self.num_states)\n        self.Q = np.zeros((self.num_states, self.num_actions))\n        self.action_space = [*range(self.num_actions)]\n        self.a = 0\n        self.cumulative_reward = 0\n        self.next_state = np.zeros(self.num_actions)\n        #self.s_next = int(self.convertTupleToIndex(self.next_state))\n        self.s_next = 0\n        self.state = np.zeros(self.num_actions)\n        #self.s = int(self.convertTupleToIndex(self.state))\n        self.s = 0\n        #self.theta = np.zeros((self.num_actions, self.num_basis_functions))\n        self.total_packets = 0\n        self.packet_no_error = 0\n        self.int_pos = random.sample(range(0,self.num_channels-1),self.num_channels-1)\n        self.int2_pos = random.sample(range(0,self.num_channels-1),self.num_channels-1)\n        self.pos = []\n        self.sensing_errors = 0\n        self.chan = []\n        self.int_freq = 0\n        self.int2_freq = 0\n        self.cent_freq = 0\n        self.tot_sensing_errors = 0\n        self.packet_errors = 0\n        self.tot_packet_errors = 0\n        self.sensing_errors_list = []\n        self.packet_errors_list = []\n        self.reward_list = []\n        self.tot_packet_errors_list = []\n        self.epsilon_count = 0\n        \n    def handle_msg_packet(self, msg):\n    \t#if self.flag == True\n    \tpacketVal = pmt.to_python(msg)\n    \tself.counter += 1\n    \t#print('packet: ' + str(self.counter))\n    \tif packetVal == False:\n    \t\tself.packet = False\n    \telse:\n    \t\tself.packet = True\n    \tself.flag_packet = True\n    \tif self.flag_sensing == True and self.flag_packet == True:\n    \t\tself.reinforcement_learning()\n    \n    def handle_msg_sensing(self, msg): \n    \tself.channels = pmt.to_python(msg)\n    \tself.channels = [0 if i < 1 else 1 for i in self.channels]\n    \tself.flag_sensing = True\n    \tself.counter_2 += 1\n    \t#print(self.counter_2)\n    \tif self.flag_sensing == True and self.flag_packet == True:\n    \t\tself.reinforcement_learning()\n    \n    def convertIndexToTuple(self,state):\n    \treturn(tuple(int(x) for x in np.base_repr(state, self.num_values, self.num_actions)[-self.num_actions::]))\n    \n    def convertTupleToIndex(self,state):\n    \treturn(int(\"\".join(str(x) for x in state), self.num_values))\n    \n    def reset(self):\n    \tfor s in range(self.num_states):\n    \t\tself.policy[s] = random.randrange(0,self.num_channels)\n    \n    def decay_epsilon(self,t):\n    \tepsilon = self.min_epsilon + (self.max_epsilon - self.min_epsilon) * np.exp(-self.decay_rate * t)\n    \treturn epsilon\n    \n    def choose_action(self,t):\n    \tp = random.uniform(0,1)\n    \tif self.count % 100 == 0:\n    \t\tself.epsilon = self.decay_epsilon(self.epsilon_count)\n    \t\tself.epsilon_count += 1\n    \t'''\n    \tif t <= int(self.time_steps*0.25):\n    \t\tepsilon = 0.90\n    \telif t <= int(self.time_steps*0.5) and t > int(self.time_steps*0.25):\n    \t\tepsilon = 0.75\n    \telif t <= int(self.time_steps*0.75) and t > int(self.time_steps*0.5):\n    \t\tepsilon = 0.25\n    \telse:\n    \t\tepsilon = 0.01\n    \t'''\n    \tif p > self.epsilon:\n    \t\tif self.count % 100 == 0:\n    \t\t\tself.policy = self.Q.argmax(axis=1)\n    \t\ta = self.policy[self.s]\n    \telse:\n    \t\ta = random.choice(list(enumerate(self.cent_freqs)))[0]\n    \treturn a\n    \n    def reward_function(self):\n    \tif self.packet == False:\n    \t\treward = 0.0\n    \telse:\n    \t\treward = 1.0\n    \t\tself.packet_no_error += 1\n    \treturn reward\n    \n    def reinforcement_learning(self):\n        self.flag_sensing = False\n        self.flag_packet = False\n        self.total_packets += 1\n        self.pos.append(self.int_freq/(1e6))\n        self.pos.append(self.int2_freq/(1e6))\n        self.pos.append(self.cent_freq/(1e6))\n\n        int_freq = self.cent_freqs[self.int_pos[self.position]]*1e6\n        int2_freq = self.cent_freqs[self.int2_pos[self.position]]*1e6\n        self.position += 1\n        if self.position == len(self.cent_freqs):\n        \tself.position = 0\n\n        self.reward = self.reward_function()\n        self.cumulative_reward += self.reward\n        self.next_state = [int(x) for x in self.channels]\n        self.s_next = int(self.convertTupleToIndex(self.next_state))\n        # update Q matrix\n        self.metric = self.alpha * (self.reward + self.gamma * np.max(self.Q[int(self.s_next), :]) - self.Q[self.s,self.a])\n        self.Q[self.s,self.a] += self.metric\n        \t\n        # update state to next state\n        self.state = self.next_state\n        self.s = int(self.convertTupleToIndex(self.state))\n\n        # choose next action\n        self.a = int(self.choose_action(self.count))\n        cent_freq = self.cent_freqs[self.a]*1e6\n        fd = (self.velocity*cent_freq)/(3*10^8)\n        #print(fd/(self.wide_samp_rate*1e6))\n\n        PMT_msg_tx =  pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_float(cent_freq))\n        PMT_msg_rx =  pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_float(-cent_freq))\n        PMT_msg_fd =  pmt.dict_add(pmt.make_dict(), pmt.intern(\"fd\"), pmt.from_float(fd))\n        self.message_port_pub(pmt.intern(self.msg_port_name_tx), PMT_msg_tx)\n        self.message_port_pub(pmt.intern(self.msg_port_name_rx), PMT_msg_rx)\n        self.message_port_pub(pmt.intern(self.msg_port_name_fd), PMT_msg_fd)\n\n\t# check for sensing errors\n        self.chan = [0 if i < 1 else 1 for i in self.channels]\n        self.int_freq = int_freq\n        self.int2_freq = int2_freq\n        self.cent_freq = cent_freq\n        # check sensing and packet errors\n        c = 0\n        if self.count != 0:\t\n        \tfor i in self.pos:\n        \t\tif c == len(self.pos)-1:\n        \t\t\tif self.pos.count(i) > 1 and self.packet != False:\n        \t\t\t\tself.packet_errors = 1\n        \t\t\tif sum(self.chan) > 2 and self.packet == False:\n        \t\t\t\tself.sensing_errors = 1\n        \t\tidx = np.where(self.cent_freqs == i)[0][0]+1\n        \t\tif self.chan[idx] == 0:\n        \t\t\tself.sensing_errors = 1\n        \t\tif sum(self.chan) > 3:\n        \t\t\tself.sensing_errors = 1\n        \t\tc += 1\n        if self.sensing_errors == 1:\n        \tself.tot_sensing_errors += 1\n        if self.packet_errors == 1:\n        \tself.tot_packet_errors += 1\n        \n        # save info\n        \n        if self.count == 0:\n        \topen(self.log_file, 'w').close()\n        \n        file1 = open(self.log_file, \"a\")\n        file1.write(\"Count: \" + str(self.count) + \" \\n\")\n        file1.write(\"Interferer 1 Frequency: \" + str(int_freq) + \" \\n\")\n        file1.write(\"Interferer 2 Frequency: \" + str(int2_freq) + \" \\n\")\n        file1.write(\"Next Frequency: \" + str(cent_freq) + \" \\n\")\n        file1.write(\"Packet: \" + str(self.packet) + \" \\n\")\n        file1.write(\"Sensing: \" + str([0 if i < 1 else 1 for i in self.channels]) + \" \\n\")\n        file1.write(\"Sensing: \" + str(self.chan) + \" \\n\")\n        file1.write(\"Reward: \" + str(self.cumulative_reward) + \" \\n\")\n        file1.write(\"Pos: \" + str(self.pos) + \" \\n \")\n        file1.write(\"Sensing Errors: \" + str(self.sensing_errors) + \" \" + str(self.tot_sensing_errors) + \" \\n\")\n        file1.write(\"Packet Errors: \" + str(self.packet_errors) + \" \" + str(self.tot_packet_errors) + \" \\n\")\n        file1.write(\"\\n\")\n        file1.close()\n        \n        # send messages\n        #PMT_msg_tx =  pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_float(cent_freq))\n        #PMT_msg_rx =  pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_float(-cent_freq))\n        PMT_msg_int =  pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_float(int_freq))\n        PMT_msg_int2 =  pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_float(int2_freq))\n        #self.message_port_pub(pmt.intern(self.msg_port_name_tx), PMT_msg_tx)\n        #self.message_port_pub(pmt.intern(self.msg_port_name_rx), PMT_msg_rx)\n        self.message_port_pub(pmt.intern(self.msg_port_name_int), PMT_msg_int)\n        self.message_port_pub(pmt.intern(self.msg_port_name_int2), PMT_msg_int2)\n        self.count += 1\n        \n        # reset variables\n        self.pos = []\n        self.sensing_errors = 0\n        self.packet_errors = 0\n        \n        if self.count % 100 == 0:\n        \tprint(self.count, self.epsilon, self.tot_sensing_errors, self.tot_packet_errors, self.cumulative_reward)\n        \tself.sensing_errors_list.append(self.tot_sensing_errors)\n        \tself.packet_errors_list.append(self.tot_packet_errors)\n        \tself.reward_list.append(self.cumulative_reward)\n        \tself.tot_packet_errors_list.append(self.total_packets-self.packet_no_error)\n        \tself.tot_sensing_errors = 0\n        \tself.tot_packet_errors = 0\n        \tself.cumulative_reward = 0\n        \tself.total_packets = 0\n        \tself.packet_no_error = 0\n        if self.count == 10000:\n        \tfile2 = open('/home/hume-users/alysemjones/rl_ofdm_dsa/data_logs/result.txt', \"a\")\n        \tfile2.write(str(self.num_channels) + \" Channels: No USRP\" + \" \\n\")\n        \tfile2.write(\"Reward: \" + str(self.reward_list) + \" \\n\")\n        \tfile2.write(\"Sensing Errors: \" + str(self.sensing_errors_list) + \" \\n\")\n        \tfile2.write(\"Packet Feedback Errors: \" + str(self.packet_errors_list) + \" \\n\")\n        \tfile2.write(\"Packet Errors: \" + str(self.tot_packet_errors_list) + \" \\n\")\n        \tfile2.write(\"\\n\")\n        \tfile2.close()\n    \t\n    def work(self, input_items, output_items):\n    \t#tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))\n    \t#self.total += len(input_items[0])\n    \t'''\n    \tif self.total <= 57600*self.count:\n    \t\tpass\n    \telse:\n    \t\tself.count += 1\n    \t\tif self.flag_sensing == True and self.flag_packet == True:\n    \t\t\tself.reinforcement_learning() \n    \t\n    \tfor tag in tagTuple:\n    \t\tif (pmt.to_python(tag.key) == 'start_RL'):\n    \t\t\tself.count += 1\n    \t\t\t#if self.flag_sensing == True and self.flag_packet == True:\n    \t\t\tif self.flag == True:\n    \t\t\t\tself.flag_sensing = False\n    \t\t\t\tself.flag_packet = False\n    \t\t\t\tself.flag = False\n    \t\t\t\tself.reinforcement_learning()\n    \t'''\n    \treturn 0\n         \n"
    log_file: '''../data_logs/rl.txt'''
    num_channels: num_channels
    time_steps: time_steps
    velocity: velocity
    wide_samp_rate: wide_samp_rate/(1e6)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_chans=8, log_file=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Sensing',   # will show up in GRC
                  in_sig=[(np.float32,num_chans)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_chans = num_chans
              self.log_file = log_file
              self.energy_vect = np.zeros(self.num_chans)
              self.start_flag = 0
              self.end_flag = 0
              self.num_samps = 0
              self.count = 0
              
              self.portName = 'energy_vec'
              self.message_port_register_out(pmt.intern(self.portName))
          
          def work(self, input_items, output_items):
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              if self.count == 0:
              	open(self.log_file, 'w').close()
              start_index = 0
              end_index = len(input_items[0])
              for tag in tagTuple:
                  if (pmt.to_python(tag.key) == 'burst_start') and ~start_index:
                      self.energy_vect = np.zeros(self.num_chans)
                      start_index = tag.offset - self.nitems_read(0)
                      self.start_flag = 1
                  if (pmt.to_python(tag.key) == 'burst_end') and ~end_index:
                      end_index = tag.offset - self.nitems_read(0)
                      self.end_flag = 1
                                   
              if self.start_flag == 1:
                  for i in range(start_index,end_index):
                      self.energy_vect += input_items[0][i]
                      self.num_samps += 1
                  
              if self.end_flag == 1:
                  #print('Num Samps: ' + str(self.num_samps))
                  self.message_port_pub(pmt.intern(self.portName), pmt.to_pmt(self.energy_vect/self.num_samps))
                  '''
                  file1 = open(self.log_file, "a")
                  file1.write("Count: " + str(self.count) + " \n")
                  file1.write("Sensing: " + str(self.energy_vect/self.num_samps) + " \n")
                  file1.write("\n")
                  file1.close()
                  '''
                  self.start_flag = 0
                  self.end_flag = 0
                  self.num_samps = 0
                  self.count += 1
              
              return len(input_items[0])
    log_file: '''../data_logs/sensing.txt'''
    num_chans: num_channels
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_rx_hier_0
  id: ofdm_rx_hier
  parameters:
    cent_freq: '-cent_freq'
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: ofdm_tx_hier_0
  id: ofdm_tx_hier
  parameters:
    back_pad: back_pad
    cent_freq: cent_freq
    front_pad: front_pad
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: pfb_channelizer_ccf_1_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '80'
    bus_structure_source: ''
    ch_map: channel_map
    nchans: num_channels
    osr: '1'
    taps: firdes.low_pass_2(1.0,1,1/num_channels/2,(1/num_channels)*0.1,80,window.WIN_BLACKMAN_HARRIS)
  states: {bus_source: true}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: wide_samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: num_channels
    type: complex
    update_time: '0.5'
  states: {bus_sink: true, state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"Transmitted OFDM Burst"'
    size: int(head_size/time_steps)
    srate: wide_samp_rate
    type: complex
    ymax: '64'
    ymin: '-64'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sensing_stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sensing_stream
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_add_xx_0, '0', channels_fading_model_0, '0']
- [blocks_add_xx_0, '0', channels_selective_fading_model_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_1, '0']
- [blocks_head_0, '0', blocks_throttle_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [channels_channel_model_0, '0', ofdm_rx_hier_0, '0']
- [channels_fading_model_0, '0', channels_channel_model_0, '0']
- [channels_selective_fading_model_0, '0', ofdm_rx_hier_0, '0']
- [epy_block_0, doppler, blocks_message_debug_0, print]
- [epy_block_0, doppler, blocks_msgpair_to_var_0, inpair]
- [epy_block_0, int2_cent_freq, analog_sig_source_x_0_0, cmd]
- [epy_block_0, int_cent_freq, analog_sig_source_x_0, cmd]
- [epy_block_0, rx_cent_freq, ofdm_rx_hier_0, cent_freq]
- [epy_block_0, tx_cent_freq, ofdm_tx_hier_0, cent_freq]
- [epy_block_1, energy_vec, epy_block_0, sensing_results]
- [ofdm_rx_hier_0, '0', blocks_null_sink_0, '0']
- [ofdm_rx_hier_0, packet_data, epy_block_0, packet_results]
- [ofdm_tx_hier_0, '0', blocks_head_0, '0']
- [ofdm_tx_hier_0, '1', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_1_0, '8', blocks_streams_to_vector_0, '8']
- [virtual_source_0, '0', pfb_channelizer_ccf_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
