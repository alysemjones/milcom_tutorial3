options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_only
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: num_channels*8
  states: {}
- name: back_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: buffer_percentage
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: cent_freq_list[0]+freq_usrp
  states: {}
- name: cent_freq_list
  id: variable
  parameters:
    value: '[int(i) for i in np.linspace(-wide_samp_rate/2+signal_samp_rate/2, wide_samp_rate/2-signal_samp_rate/2, num_channels)]'
  states: {}
- name: cent_freq_list
  id: variable
  parameters:
    value: '[int(i) for i in np.arange(-wide_samp_rate/2, wide_samp_rate/2, wide_samp_rate/num_channels)]'
  states: {state: disabled}
- name: cent_freq_rx
  id: variable
  parameters:
    value: '-cent_freq_list[0]+freq_usrp'
  states: {}
- name: channel_map
  id: variable
  parameters:
    value: '[int(num_channels/2) + i*1 if i < int(num_channels/2) else -int(num_channels/2)+i*1 for i in range(num_channels)]'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: freq_fosphor
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_usrp
  id: variable
  parameters:
    value: 2.35e9
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(signal_samp_rate/(signal_samp_rate))*time_steps)
  states: {}
- name: linear_gain
  id: variable
  parameters:
    value: '550'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '8'
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '11'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: num_data_symbs*(64+4)+num_header_symbs*(64+4)
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: num_zeros
  id: variable
  parameters:
    value: '1100'
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '35'
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 64*15e3/5
  states: {}
- name: snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,1/num_channels/2,(1/num_channels)*0.1,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '35'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: signal_samp_rate*num_channels
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_volt
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: int(cent_freq-freq_usrp)
    offset: '0'
    phase: '0.0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2.5'
    freq: cent_freq_list[1]
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2.5'
    freq: cent_freq_list[2]
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: int(-cent_freq+freq_usrp)
    offset: '0'
    phase: '0.0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_channels
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../data/rx_bits.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../data/tx_bits.dat
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: linear_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/sqrt(fft_len)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: num_channels
    type: complex
  states: {bus_sink: true, state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: burst_start
    type: complex
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr
      import time
      import random


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,num_channels=8,wide_samp_rate=2e6, cent_freqs=[],log_file=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Cognitive Engine',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_channels = num_channels
              self.wide_samp_rate = wide_samp_rate
              self.cent_freqs = cent_freqs
              self.log_file = log_file
              self.samp_rate = int(self.wide_samp_rate/(1e6))
              self.msg_port_name_tx = 'tx_freq'
              self.msg_port_name_rx = 'rx_freq'
              self.msg_port_name_int = 'int_cent_freq'
              self.msg_port_name_int2 = 'int2_cent_freq'
              #self.msg_port_name_reward = 'reward'
              self.msg_input_sensing = 'sensing_results'
              self.msg_input_packet = 'packet_results'
              self.msg_input_change_rx = 'rx_handler_psd'
              #self.msg_input_change_rx2 = 'rx_handler_chan'
              self.message_port_register_out(pmt.intern(self.msg_port_name_tx))
              self.message_port_register_out(pmt.intern(self.msg_port_name_rx))
              self.message_port_register_out(pmt.intern(self.msg_port_name_int))
              self.message_port_register_out(pmt.intern(self.msg_port_name_int2))
              #self.message_port_register_out(pmt.intern(self.msg_port_name_reward))
              self.message_port_register_in(pmt.intern(self.msg_input_sensing))
              self.set_msg_handler(pmt.intern(self.msg_input_sensing), self.handle_msg_sensing)
              self.message_port_register_in(pmt.intern(self.msg_input_packet))
              self.set_msg_handler(pmt.intern(self.msg_input_packet), self.handle_msg_packet)
              self.message_port_register_in(pmt.intern(self.msg_input_change_rx))
              self.set_msg_handler(pmt.intern(self.msg_input_change_rx), self.handle_msg_rx_freq)
              #self.message_port_register_in(pmt.intern(self.msg_input_change_rx2))
              #self.set_msg_handler(pmt.intern(self.msg_input_change_rx2), self.handle_msg_rx_freq2)
              #self.cent_freqs = np.arange(-int((self.samp_rate/2)+(self.samp_rate/(self.num_channels*2))),int((self.samp_rate/2)+(self.samp_rate/(self.num_channels*2))),self.samp_rate/self.num_channels)
              #self.cent_freqs = self.cent_freqs[1:]
              print(self.cent_freqs)
              self.position = 0
              self.count_sensor = 0
              self.count_packet = 0
              self.counter = 0
              self.count = 0
              self.packet = False
              self.packet_flag = False
              self.sensor_flag = False
              self.cent_freq = -500000
              self.int_freq = -83333
              self.int2_freq = 83333
              self.packet_errors = 0
              self.tot_packet_errors = 0
              self.sensing_errors = 0
              self.tot_sensing_errors = 0
              self.pos = []
              self.int_pos = random.sample(range(0,self.num_channels-1),self.num_channels-1)
              self.int2_pos = random.sample(range(0,self.num_channels-1),self.num_channels-1)
              ### RL Stuff ### 
              self.min_epsilon = 0.001
              self.max_epsilon = 1
              self.decay_rate = 0.08
              self.alpha = 0.9
              self.gamma = 0.1
              self.values = [0,1]
              self.num_values = len(self.values)
              self.time_window = 1
              self.num_actions = self.num_channels
              self.num_states = self.num_values**(self.num_actions*self.time_window)
              self.epsilon = 0
              self.policy = np.zeros(self.num_states)
              self.Q = np.zeros((self.num_states, self.num_actions))
              self.action_space = [*range(self.num_actions)]
              self.a = 0
              self.cumulative_reward = 0
              self.next_state = np.zeros(self.num_actions)
              self.s_next = 0
              self.state = np.zeros(self.num_actions)
              self.s = 0
              self.sensing_errors_list = []
              self.reward_list = []
              self.tot_packet_errors_list = []
              self.epsilon_count = 0
              self.reward = 0
              self.cumulative_reward_list = []
              self.packet_error_list = []
              self.sensing_error_list = []
              self.previous_reward = 0
              self.count_previous = 0
              self.change = 0
              self.empty = []
              self.previous_state = []
              self.start_time = 0
              self.time_diff = 0
              self.time_diff_avg = 0
              self.time_diff_avg_list = []
          
          def handle_msg_sensing(self, msg): 
          	self.channels = pmt.to_python(msg)
          	if self.count == 0:
          	   print(self.channels)
          	self.channels = [0 if i < 2 else 1 for i in self.channels]
          	self.count_sensor += 1
          	self.sensor_flag = True
          	if self.count_sensor < 100*102:
          	   self.pos = []
          	   self.sensing_errors = 0
          	   self.packet_errors = 0
          	   self.reinforcement_learning()

          def handle_msg_packet(self, msg):
          	packetVal = pmt.to_python(msg)
          	self.counter += 1
          	if packetVal == False:
          		self.packet = False
          	else:
          		self.packet = True
          		self.count_packet += 1
          		self.packet_flag = True
          	#if self.counter < 1000:
          	#    self.change_frequency()
          	#    PMT_msg_send =  pmt.dict_add(pmt.make_dict(), pmt.intern("transmit"), pmt.to_pmt('Send Frame'))
          	#    self.message_port_pub(pmt.intern(self.msg_port_name_send), PMT_msg_send)
          	    #zmq_socket_packet.send(pmt.serialize_str(pmt.to_pmt('Send Frame')))
          	   
          	#if self.sensor_flag == True and self.packet_flag == True:
          	#       self.check_synch()
          
          #def handle_msg_rx_freq2(self, msg):
          #    self.start_time = time.time()
              
          def handle_msg_rx_freq(self, msg):
              end_time = time.time()
              self.check_sensing_errors()
              #print(self.pos, self.channels)
              #print(self.count, self.count_packet, self.counter, self.pos, self.channels, self.packet, self.tot_sensing_errors, self.tot_packet_errors)
              self.time_diff += end_time - self.start_time
              #print(self.int_pos, self.int2_pos)
              if self.packet == True:
                 self.reward = 1
              else:
                 self.reward = 0
              if self.count % 100 == 0:
                 '''
                 if self.count > 100*45 and self.change == 0:
                    if self.cumulative_reward < 95:
                       self.epsilon_count = 0
                       self.count_previous = 0
                       self.change = 1
                 '''
                 #PMT_msg_reward =  pmt.dict_add(pmt.make_dict(), pmt.intern("reward"), pmt.from_float(100-self.cumulative_reward))
                 #self.message_port_pub(pmt.intern(self.msg_port_name_reward), PMT_msg_reward)  
                 self.time_diff_avg = self.time_diff/100
                # print(self.count, self.epsilon, self.count_packet, self.previous_reward, self.cumulative_reward, self.tot_sensing_errors, self.tot_packet_errors, self.time_diff_avg)
                 print(self.count, self.cumulative_reward)
                 self.previous_reward = self.cumulative_reward
                 self.cumulative_reward_list.append(self.cumulative_reward)
                 self.packet_error_list.append(self.tot_packet_errors)
                 self.sensing_error_list.append(self.tot_sensing_errors)
                 self.time_diff_avg_list.append(self.time_diff_avg)
                 self.cumulative_reward = 0
                 self.tot_sensing_errors = 0
                 self.tot_packet_errors = 0
                 self.count_packet = 0
                 self.time_diff = 0
                 self.time_diff_avg = 0
              self.packet_flag = False
              self.count += 1
              self.packet = False
              '''
              if self.count == 100*40:
                 print(self.int_pos, self.int2_pos)
                 self.int_pos = random.sample(range(0,self.num_channels-1),self.num_channels-1)
                 self.int2_pos = random.sample(range(0,self.num_channels-1),self.num_channels-1)    
                 print(self.int_pos, self.int2_pos)
                 self.position = 0      
              '''  
              if self.count == 10000:
                 self.save_data()
          
          def save_data(self):
              f = open(self.log_file, "a")
              f.write("Reward: " + str(self.cumulative_reward_list) + "\n")
              f.write("Sensing Errors: " + str(self.sensing_error_list) + "\n")
              f.write("Packet Errors: " + str(self.packet_error_list) + "\n")
              f.write("Time diff: " + str(self.time_diff_avg_list) + "\n")
              f.write("\n")
              f.close()
          
          def check_sensing_errors(self):
              c = 0
              idx_list = []
              if self.count != 0:
              	for i in self.pos:
              		idx = np.where(np.array(self.cent_freqs) == i)[0][0]
              		idx_list.append(idx)
              		if self.channels[idx] == 0:
              			self.sensing_errors = 1
              		if sum(self.channels) > 3:
              			self.sensing_errors = 1
              		c += 1
              	if (idx_list[1] == idx_list[0]) and self.packet != False:
              	    self.packet_errors = 1
              	if (idx_list[2] == idx_list[0]) and self.packet != False:
              	    self.packet_errors = 1
              	if sum(self.channels) == 1 and self.packet != False:
              	    self.packet_errors = 1
              	if (idx_list[1] == idx_list[2]) and (idx_list[0] != idx_list[1]):
              	    if self.packet != True:
              	       self.packet_errors = 1
              	    else:
              	       self.packet_errors = 0
              if self.sensing_errors == 1:
                     self.tot_sensing_errors += 1
              if self.packet_errors == 1:
                     self.tot_packet_errors += 1
              #print(idx_list, self.packet, self.tot_packet_errors)

          def convertIndexToTuple(self,state):
          	return(tuple(int(x) for x in np.base_repr(state, self.num_values, self.num_actions)[-self.num_actions::]))
          
          def convertTupleToIndex(self,state):
          	return(int("".join(str(x) for x in state), self.num_values))
          
          def reset(self):
          	for s in range(self.num_states):
          		self.policy[s] = random.randrange(0,self.num_channels)
          
          def decay_epsilon(self,t):
          	epsilon = self.min_epsilon + (self.max_epsilon - self.min_epsilon) * np.exp(-self.decay_rate * t)
          	return epsilon

          def choose_action(self,t):
          	p = random.uniform(0,1)
          	if self.count % 100 == 0:
          		self.epsilon = self.decay_epsilon(self.epsilon_count)
          		self.epsilon_count += 1
          	#if self.count == 100*20:
          	#	print(self.count)
          	#	self.epsilon_count == 0
          	'''
          	if t <= int(self.time_steps*0.25):
          		epsilon = 0.90
          	elif t <= int(self.time_steps*0.5) and t > int(self.time_steps*0.25):
          		epsilon = 0.75
          	elif t <= int(self.time_steps*0.75) and t > int(self.time_steps*0.5):
          		epsilon = 0.25
          	else:
          		epsilon = 0.01
          	'''
          	if p > self.epsilon:
          		if self.count % 100 == 0:
          			self.policy = self.Q.argmax(axis=1)
          		a = self.policy[self.s]
          	else:
          		a = random.choice(list(enumerate(self.cent_freqs)))[0]
          	return a
          
          def reinforcement_learning(self):
              if self.count == 0:
                      self.pos.append(int(self.cent_freqs[0]))
                      self.pos.append(int(self.int_freq))
                      self.pos.append(int(self.int2_freq))
              else:
                      self.pos.append(int(self.cent_freq))
                      self.pos.append(int(self.int_freq))
                      self.pos.append(int(self.int2_freq))
              
              self.cumulative_reward += self.reward
              self.next_state = [int(x) for x in self.channels]
              self.s_next = int(self.convertTupleToIndex(self.next_state))
              # update Q matrix
              self.metric = self.alpha * (self.reward + self.gamma * np.max(self.Q[int(self.s_next), :]) - self.Q[self.s,self.a])
              self.Q[self.s,self.a] += self.metric
              	
              # update state to next state
              self.state = self.next_state
              self.s = int(self.convertTupleToIndex(self.state))

              # choose next action
              self.a = int(self.choose_action(self.count))
              self.cent_freq = self.cent_freqs[self.a]
              
              #self.cent_freq = self.cent_freqs[self.position]
              #self.int_freq = self.cent_freqs[self.int_pos[self.position]]
              #self.int2_freq = self.cent_freqs[self.int2_pos[self.position]]
              self.int_freq = self.cent_freqs[3]
              self.int2_freq = self.cent_freqs[self.position]
              self.position += 1
              if self.position == len(self.cent_freqs)-1:
                 self.position = 0
              
              #self.empty = [i for i,val in enumerate(self.channels) if val==0]
              #idx = random.choice(self.empty)
              #self.cent_freq = self.cent_freqs[idx]
              
              PMT_msg_tx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(self.cent_freq))
              self.message_port_pub(pmt.intern(self.msg_port_name_tx), PMT_msg_tx)
              PMT_msg_rx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(-self.cent_freq))
              self.message_port_pub(pmt.intern(self.msg_port_name_rx), PMT_msg_rx)
              PMT_msg_int =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(self.int_freq))
              self.message_port_pub(pmt.intern(self.msg_port_name_int), PMT_msg_int)
              PMT_msg_int2 =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(self.int2_freq))
              self.message_port_pub(pmt.intern(self.msg_port_name_int2), PMT_msg_int2)  
                        
          def work(self, input_items, output_items):
              return len(input_items[0])
    cent_freqs: cent_freq_list
    log_file: '''../data_logs/results.txt'''
    num_channels: num_channels
    wide_samp_rate: wide_samp_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_chans=8, log_file=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Sensing',   # will show up in GRC
                  in_sig=[(np.float32,num_chans)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_chans = num_chans
              self.log_file = log_file
              self.energy_vect = np.zeros(self.num_chans)
              self.start_flag = 0
              self.end_flag = 0
              self.num_samps = 0
              self.count = 0
              self.count_packet_len = 1
              
              self.portName = 'energy_vec'
              self.portName2 = 'packet_len_chan'
              self.message_port_register_out(pmt.intern(self.portName))
              self.message_port_register_out(pmt.intern(self.portName2))   
          
          def work(self, input_items, output_items):
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              if self.count == 0:
              	open(self.log_file, 'w').close()
              start_index = 0
              start_index_packet = 0
              end_index = len(input_items[0])
              for tag in tagTuple:
                  if (pmt.to_python(tag.key) == 'burst_start') and ~start_index:
                      self.energy_vect = np.zeros(self.num_chans)
                      start_index = tag.offset - self.nitems_read(0)
                      self.start_flag = 1
                  if (pmt.to_python(tag.key) == 'burst_end') and ~end_index:
                      end_index = tag.offset - self.nitems_read(0)
                      self.end_flag = 1
                  if (pmt.to_python(tag.key) == 'packet_len') and ~start_index:
                      start_index_packet = tag.offset - self.nitems_read(0)
                      if self.count_packet_len == self.num_chans:
                         if self.count > 0:
                              #time.sleep(0.1)
                              self.message_port_pub(pmt.intern(self.portName2), pmt.to_pmt('change_rx_freq'))
                         #print('hello ' + str(self.count))
                         #print(self.count_packet_len)
                         self.count_packet_len = 1
                      else:
                         self.count_packet_len += 1
                                   
              if self.start_flag == 1:
                  for i in range(start_index,end_index):
                      self.energy_vect += input_items[0][i]
                      self.num_samps += 1
                  
              if self.end_flag == 1:
                  #print('Num Samps: ' + str(self.num_samps))
                  self.message_port_pub(pmt.intern(self.portName), pmt.to_pmt(self.energy_vect/self.num_samps))
                  #time.sleep(0.001)
                  #self.message_port_pub(pmt.intern(self.portName2), pmt.to_pmt('change_rx_freq'))
                  '''
                  file1 = open(self.log_file, "a")
                  file1.write("Count: " + str(self.count) + " \n")
                  file1.write("Sensing: " + str(self.energy_vect/self.num_samps) + " \n")
                  file1.write("\n")
                  file1.close()
                  '''
                  self.start_flag = 0
                  self.end_flag = 0
                  self.num_samps = 0
                  self.count += 1
              
              return len(input_items[0])
    log_file: '''/home/hume-users/alysemjones/rl_ofdm_dsa/data_logs/sensing.txt'''
    num_chans: num_channels
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    N: N
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import math

      class blk(gr.sync_block):
          def __init__(self, num_chans=4, N=64):
              gr.sync_block.__init__(
                  self,
                  name='PSD Sensing',
                  in_sig=[(np.float32,N)],
                  out_sig=None
              )
              self.num_chans = num_chans
              self.N = N
                     
              self.total_samps = 0
              self.total_epochs = 0  
              self.start_flag = 0
              self.fft_count = 0
                      
              self.portName = 'energy_vec'
              self.portName2 = 'packet_len_psd'
              self.message_port_register_out(pmt.intern(self.portName))   
              self.message_port_register_out(pmt.intern(self.portName2))     
             
              self.energy_vect = np.zeros(self.num_chans)
              
          def work(self, input_items, output_items):
              total_items = input_items[0].shape[0] * input_items[0].shape[1]
              self.total_samps += total_items
              tagTuple = self.get_tags_in_window(0, 0, input_items[0].shape[0])

              tags_found = []
              if not len(tagTuple) == 0:       
                  for tag in tagTuple: 
                      if not pmt.to_python(tag.key) == 'packet_len':
                         tag_vect_num = int(input_items[0].shape[0] - ((self.total_samps - tag.offset*self.N)/self.N))
                         tags_found.append([pmt.to_python(tag.key), tag_vect_num])
                      if (pmt.to_python(tag.key) == 'burst_start') and self.total_epochs > 0:
                          self.message_port_pub(pmt.intern(self.portName2), pmt.to_pmt('change_rx_freq'))
                         
                      
              for k in range(input_items[0].shape[0]):
                  if not len(tags_found) == 0:        
                      if tags_found[0][1] == k and tags_found[0][0] == 'burst_start':                              
                          self.fft_count = 0
                          self.start_flag = 1
                          self.total_epochs += 1
                          self.energy_vect = np.zeros(self.num_chans)
                          tags_found.pop(0)

                  if self.start_flag == 1:
                      chan_vals = input_items[0][k].reshape((self.num_chans, int(self.N/self.num_chans)))
                      self.fft_count += 1
                      for kk in range(self.num_chans):
                          self.energy_vect[kk] += np.mean(chan_vals[kk])
                              
                  if not len(tags_found) == 0:
                      if tags_found[0][1] == k and tags_found[0][0] == 'burst_end':                                
                          self.start_flag = 0                
                          #print('Finished Epoch #', self.total_epochs, ', FFTs Calculated: ', self.fft_count)
                          self.message_port_pub(pmt.intern(self.portName), pmt.to_pmt(self.energy_vect/self.fft_count))
                          tags_found.pop(0)                     
                                      
              return len(input_items[0])                    
    num_chans: num_channels
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: wide_samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_samp_rate/2
    gain: '1'
    interp: '1'
    samp_rate: wide_samp_rate
    type: interp_fir_filter_ccf
    width: 0.25*signal_samp_rate/2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_samp_rate/2
    gain: '1'
    interp: '1'
    samp_rate: wide_samp_rate
    type: interp_fir_filter_ccf
    width: 0.25*signal_samp_rate/2
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: signal_samp_rate/wide_samp_rate
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: wide_samp_rate/signal_samp_rate
    type: complex
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_rx_hier_5g_0
  id: ofdm_rx_hier_5g
  parameters:
    cent_freq: int(-cent_freq+freq_usrp)
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: ofdm_tx_hier_5g_0
  id: ofdm_tx_hier_5g
  parameters:
    back_pad: back_pad
    cent_freq: buffer_percentage
    front_pad: front_pad
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: pfb_channelizer_ccf_1_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '80'
    bus_structure_source: ''
    ch_map: channel_map
    nchans: num_channels
    osr: '1'
    taps: taps
  states: {bus_source: true, state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_usrp
    dev_addr: addr=192.168.2.4
    gain0: tx_gain
    samp_rate: wide_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_usrp
    dev_addr: addr=192.168.1.4
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: wide_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sensing_stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sensing_stream
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_1, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_add_xx_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_add_xx_0, '0', pfb_channelizer_ccf_1_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_2, '0']
- [blocks_complex_to_mag_squared_0_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '2']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_vector_0, '0']
- [epy_block_0_0, int2_cent_freq, analog_sig_source_x_0_0, cmd]
- [epy_block_0_0, int_cent_freq, analog_sig_source_x_0_0_0, cmd]
- [epy_block_0_0, rx_freq, analog_sig_source_x_0_1, cmd]
- [epy_block_0_0, tx_freq, analog_sig_source_x_0, cmd]
- [epy_block_0_0, tx_freq, ofdm_tx_hier_5g_0, send_burst]
- [epy_block_1, energy_vec, blocks_message_debug_0, print]
- [epy_block_1, energy_vec, epy_block_0_0, sensing_results]
- [epy_block_2, energy_vec, epy_block_0_0, sensing_results]
- [epy_block_2, packet_len_psd, epy_block_0_0, rx_handler_psd]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0, '0']
- [mmse_resampler_xx_0_0, '0', ofdm_rx_hier_5g_0, '0']
- [ofdm_rx_hier_5g_0, '0', blocks_file_sink_0, '0']
- [ofdm_rx_hier_5g_0, packet_data, epy_block_0_0, packet_results]
- [ofdm_tx_hier_5g_0, '0', mmse_resampler_xx_0, '0']
- [ofdm_tx_hier_5g_0, '1', blocks_file_sink_0_0, '0']
- [pfb_channelizer_ccf_1_0, '8', blocks_streams_to_vector_0, '8']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.9.6.0-rc1
