options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_only
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: back_pad
  id: variable
  parameters:
    value: '500'
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: '500'
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(signal_samp_rate/(signal_samp_rate))*time_steps)
  states: {}
- name: linear_gain
  id: variable
  parameters:
    value: '8.5'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: num_data_symbs*80+num_header_symbs*80
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,(1/32)-0.01,0.01,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '64'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 8*signal_samp_rate
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../data/tx_bits.dat
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: head_size
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/fft_len
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_tx_hier_usrp_0
  id: ofdm_tx_hier_usrp
  parameters:
    back_pad: back_pad
    cent_freq: cent_freq
    front_pad: front_pad
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.35e9
    dev_addr: addr=192.168.2.4
    gain0: tx_gain
    samp_rate: signal_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_head_0, '0']
- [ofdm_tx_hier_usrp_0, '0', blocks_multiply_const_vxx_1, '0']
- [ofdm_tx_hier_usrp_0, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.6.0-rc1
