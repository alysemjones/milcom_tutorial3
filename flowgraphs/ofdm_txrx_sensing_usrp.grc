options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_sensing
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: back_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: block_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+80+800)*(wide_samp_rate/(1e6))/num_channels)
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: channel_map
  id: variable
  parameters:
    value: '[int(num_channels/2) + i*1 if i < int(num_channels/2) else -int(num_channels/2)+i*1 for i in range(num_channels)]'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(wide_samp_rate/(signal_samp_rate))*time_steps)
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '8'
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: num_data_symbs*80+num_header_symbs*80
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: num_zeros
  id: variable
  parameters:
    value: '1800'
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 1e6/10
  states: {}
- name: snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,(1/32)-0.01,0.01,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 32e6/10
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_channels
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../data/rx_bits.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../data/rx_bits.dat
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: head_size
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3.6'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/20
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: num_channels
    type: complex
  states: {bus_sink: true}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,num_channels=8,wide_samp_rate=2e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Freq Control',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig = []
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_channels = num_channels
              self.wide_samp_rate = wide_samp_rate
              self.samp_rate = int(self.wide_samp_rate/(1e6))
              self.msg_port_name_tx = 'tx_cent_freq'
              self.msg_port_name_rx = 'rx_cent_freq'
              self.message_port_register_out(pmt.intern(self.msg_port_name_rx))
              self.message_port_register_out(pmt.intern(self.msg_port_name_tx))
              self.cent_freqs = np.arange(int(-(self.samp_rate/2)+1),int(self.samp_rate/2),1/8)
              self.position = 0
              self.count = 0

          def work(self, input_items, output_items):
              tag_tuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tag_tuple:
                  if (pmt.to_python(tag.key) == 'packet_len'):
                      cent_freq = self.cent_freqs[self.position]*1e6
                      self.position += 1
                      self.count += 1
                      print(self.count)
                      if self.position == len(self.cent_freqs):
                          self.position = 0
                      PMT_msg_tx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(cent_freq))
                      PMT_msg_rx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(-cent_freq))
                      self.message_port_pub(pmt.intern(self.msg_port_name_tx), PMT_msg_tx)
                      self.message_port_pub(pmt.intern(self.msg_port_name_rx), PMT_msg_rx)
              
              return len(input_items[0])
    num_channels: num_channels
    wide_samp_rate: wide_samp_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_chans=8):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32,num_chans)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_chans = num_chans
              self.energy_vect = np.zeros(self.num_chans)
              self.start_flag = 0
              self.end_flag = 0
              self.num_samps = 0
              
              self.portName = 'energy_vec'
              self.message_port_register_out(pmt.intern(self.portName))
          
          def work(self, input_items, output_items):
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
                      
              start_index = 0
              end_index = len(input_items[0])
              for tag in tagTuple:
                  if (pmt.to_python(tag.key) == 'burst_start') and ~start_index:
                      self.energy_vect = np.zeros(self.num_chans)
                      start_index = tag.offset - self.nitems_read(0)
                      self.start_flag = 1
                  if (pmt.to_python(tag.key) == 'burst_end') and ~end_index:
                      end_index = tag.offset - self.nitems_read(0)
                      self.end_flag = 1
                                   
              if self.start_flag == 1:
                  for i in range(start_index,end_index):
                      self.energy_vect += input_items[0][i]
                      self.num_samps += 1
                  
              if self.end_flag == 1:
                  print('Num Samps: ' + str(self.num_samps))
                  self.message_port_pub(pmt.intern(self.portName), pmt.to_pmt(self.energy_vect/self.num_samps))
                  self.start_flag = 0
                  self.end_flag = 0
                  self.num_samps = 0
              
              return len(input_items[0])
    num_chans: num_channels
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_rx_hier_0
  id: ofdm_rx_hier
  parameters:
    cent_freq: '-cent_freq'
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: ofdm_tx_hier_0
  id: ofdm_tx_hier
  parameters:
    back_pad: back_pad
    cent_freq: cent_freq
    front_pad: front_pad
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: pfb_channelizer_ccf_1_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '80'
    bus_structure_source: ''
    ch_map: channel_map
    nchans: num_channels
    osr: '1'
    taps: firdes.low_pass_2(1.0,1,1/num_channels/2,(1/num_channels)*0.1,80,window.WIN_BLACKMAN_HARRIS)
  states: {bus_source: true}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,1,1,1
    name: '"Transmitted OFDM Burst"'
    size: int(head_size/time_steps)
    srate: wide_samp_rate
    type: complex
    ymax: '64'
    ymin: '-64'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.35e9
    dev_addr: addr=192.168.2.4
    gain0: '60'
    samp_rate: wide_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2.35e9
    dev_addr: addr=192.168.1.4
    rx_agc0: Enabled
    samp_rate: wide_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sensing_stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sensing_stream
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', epy_block_1, '0']
- [blocks_head_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', ofdm_rx_hier_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_head_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, rx_cent_freq, ofdm_rx_hier_0, cent_freq]
- [epy_block_0, tx_cent_freq, ofdm_tx_hier_0, cent_freq]
- [epy_block_1, energy_vec, blocks_message_debug_0, print]
- [ofdm_rx_hier_0, '0', blocks_file_sink_0, '0']
- [ofdm_rx_hier_0, '0', blocks_null_sink_0, '0']
- [ofdm_tx_hier_0, '0', blocks_multiply_const_vxx_1, '0']
- [ofdm_tx_hier_0, '0', epy_block_0, '0']
- [ofdm_tx_hier_0, '1', blocks_file_sink_0_0, '0']
- [ofdm_tx_hier_0, '1', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_1_0, '8', blocks_streams_to_vector_0, '8']
- [uhd_usrp_source_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', pfb_channelizer_ccf_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.6.0-rc1
