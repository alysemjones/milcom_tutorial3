options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_randFreq
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: back_pad
  id: variable
  parameters:
    value: '3500'
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: 0e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: '3500'
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(wide_samp_rate/(signal_samp_rate))*time_steps)
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '8'
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: num_data_symbs*80+num_header_symbs*80
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: num_zeros
  id: variable
  parameters:
    value: '3500'
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 1e6/16
  states: {}
- name: snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,(1/32)-0.01,0.01,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 32e6/16
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: head_size
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '233'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/20
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr
      import numpy as np


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,num_channels=8,wide_samp_rate=2e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Freq Control',   # will show up in GRC
                  in_sig=[],
                  out_sig = []
              )
              self.num_channels = num_channels
              self.wide_samp_rate = wide_samp_rate
              self.samp_rate = int(self.wide_samp_rate/(1e6))
              self.msg_input_packet = 'packet_results'
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_port_name_tx = 'tx_cent_freq'
              self.msg_port_name_rx = 'rx_cent_freq'
              self.message_port_register_out(pmt.intern(self.msg_port_name_rx))
              self.message_port_register_out(pmt.intern(self.msg_port_name_tx))
              self.cent_freqs = np.arange(int(-(self.samp_rate/2)+1),int(self.samp_rate/2),1/8)

              self.message_port_register_in(pmt.intern(self.msg_input_packet))
              self.set_msg_handler(pmt.intern(self.msg_input_packet), self.handle_msg_packet)
              
          def handle_msg_packet(self, msg):
              cent_freq = np.random.choice(self.cent_freqs)*1e6
              #print(cent_freq)
              PMT_msg_tx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(cent_freq))
              PMT_msg_rx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(-cent_freq))
              self.message_port_pub(pmt.intern(self.msg_port_name_tx), PMT_msg_tx)
              self.message_port_pub(pmt.intern(self.msg_port_name_rx), PMT_msg_rx)    	
          		
          def work(self, input_items, output_items):
              return 0
    num_channels: num_channels
    wide_samp_rate: wide_samp_rate
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: wide_samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_rx_hier_0
  id: ofdm_rx_hier
  parameters:
    cent_freq: '-cent_freq'
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: ofdm_tx_hier_0
  id: ofdm_tx_hier
  parameters:
    back_pad: back_pad
    cent_freq: cent_freq
    front_pad: front_pad
    signal_samp_rate: signal_samp_rate
    wide_samp_rate: wide_samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.35e9
    dev_addr: '"serial=310DF34"'
    gain0: '62'
    samp_rate: wide_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2.35e9
    dev_addr: '"serial=310DF34"'
    gain0: '10'
    samp_rate: wide_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', ofdm_rx_hier_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_head_0, '0']
- [epy_block_0, rx_cent_freq, ofdm_rx_hier_0, cent_freq]
- [epy_block_0, tx_cent_freq, ofdm_tx_hier_0, cent_freq]
- [ofdm_rx_hier_0, '0', blocks_null_sink_0_0, '0']
- [ofdm_rx_hier_0, packet_data, epy_block_0, packet_results]
- [ofdm_tx_hier_0, '0', blocks_multiply_const_vxx_1, '0']
- [ofdm_tx_hier_0, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
