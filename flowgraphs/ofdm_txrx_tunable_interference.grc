options:
  parameters:
    author: Alyse Jones and William "Chris" Headley
    generate_options: qt_gui
    id: ofdm_txrx_only
    output_language: python
    run_options: run
    title: OFDM End-to-End Stream Testing (with GUI)
  states: {}

blocks:
- name: back_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: 0e6
  states: {}
- name: cent_freq_list
  id: variable
  parameters:
    value: '[int(i) for i in np.linspace(-wide_samp_rate/2+signal_samp_rate/2, wide_samp_rate/2-signal_samp_rate/2, num_channels)]'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(64)
  states: {}
- name: front_pad
  id: variable
  parameters:
    value: num_zeros
  states: {}
- name: head_size
  id: variable
  parameters:
    value: int((front_pad+back_pad+num_samps)*(wide_samp_rate/(1e6))*time_steps)
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: pow(1.0/(fft_len*2*pow(10.0,snr/10.0)),0.5)
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '8'
  states: {}
- name: num_data_symbs
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_header_symbs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_samps
  id: variable
  parameters:
    value: num_data_symbs*80+num_header_symbs*80
  states: {}
- name: num_samps_per_step
  id: variable
  parameters:
    value: head_size/time_steps
  states: {}
- name: num_zeros
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: rand_seed
  id: variable
  parameters:
    value: int(time.time())
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: float(wide_samp_rate/signal_samp_rate)
  states: {}
- name: signal_samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0,1,(1/32)-0.01,0.01,80,window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: time_steps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_volt
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: cent_freq
    offset: '0'
    phase: '0.0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: cent_freq_list[4]
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../data/rx_bits.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../data/tx_bits.dat
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,cent_freqs=[],time_steps=10,cent_freq=0e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Cognitive Engine',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.cent_freqs = cent_freqs
              self.time_steps = time_steps
              self.cent_freq = cent_freq
              self.msg_port_name_tx = 'tx_cent_freq'
              self.msg_port_name_rx = 'rx_cent_freq'
              self.msg_input_packet = 'packet_results'
              self.count = 0
              self.pos = 0
              self.message_port_register_out(pmt.intern(self.msg_port_name_rx))
              self.message_port_register_out(pmt.intern(self.msg_port_name_tx))
              # add in message ports for interference here
              self.msg_port_name_int = 'int_cent_freq'
              self.message_port_register_out(pmt.intern(self.msg_port_name_int))
              self.message_port_register_in(pmt.intern(self.msg_input_packet))
              self.set_msg_handler(pmt.intern(self.msg_input_packet), self.handle_msg_packet)
              self.start_time = time.time()

          def handle_msg_packet(self, msg):
          	# record packet results from the receiver
          	packetVal = pmt.to_python(msg)
          	if packetVal == False:
          		self.packet = False
          		pass
          	else:
          		self.packet = True
          		
          	# transmit again when the following conditions are met
          	if self.count == 0 or self.packet == True or (time.time()-self.start_time > 0.05):
          		self.control_freq() # decides the next action(s)
          		self.count += 1
          		self.start_time = time.time()
          
          def control_freq(self):
          	if self.count < self.time_steps:
          		self.previous_freq = self.cent_freq
          		self.cent_freq = self.cent_freqs[self.pos]
          		# add interference control here
          		int_freq = self.cent_freqs[5]
          		# send new center frequency to the transmitter and receiver
          		PMT_msg_tx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(self.cent_freq))
          		PMT_msg_rx =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(-self.cent_freq))
          		self.message_port_pub(pmt.intern(self.msg_port_name_tx), PMT_msg_tx)
          		self.message_port_pub(pmt.intern(self.msg_port_name_rx), PMT_msg_rx)
          		# send new frequency to the interferer here
          		PMT_msg_int =  pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_float(int_freq))
          		self.message_port_pub(pmt.intern(self.msg_port_name_int), PMT_msg_int)
          		# enforce diagonal hopping
          		if self.pos == (len(self.cent_freqs)-1):
          			self.pos = 0
          		else:
          			self.pos += 1  
          		print(self.count,int_freq,self.previous_freq,self.packet)	

          def work(self, input_items, output_items):
              return len(input_items[0])
    cent_freq: cent_freq
    cent_freqs: cent_freq_list
    time_steps: time_steps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import erfc
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_samp_rate/2
    gain: '1'
    interp: '1'
    samp_rate: wide_samp_rate
    type: interp_fir_filter_ccf
    width: 0.25*signal_samp_rate/2
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: signal_samp_rate/wide_samp_rate
    type: complex
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Tunable Variables
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Fixed Variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Derived Variables
  states: {}
- name: ofdm_rx_hier_usrp_0
  id: ofdm_rx_hier_usrp
  parameters:
    cent_freq: cent_freq
    signal_samp_rate: signal_samp_rate
    threshold: '0.95'
    wide_samp_rate: wide_samp_rate
  states: {}
- name: ofdm_tx_hier_usrp_0
  id: ofdm_tx_hier_usrp
  parameters:
    back_pad: back_pad
    buffer_percentage: '0.1'
    front_pad: front_pad
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"OFDM Burst"'
    size: int(head_size/time_steps)
    srate: wide_samp_rate
    type: complex
    ymax: '64'
    ymin: '-64'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', blocks_tag_gate_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_tag_gate_0, '0', ofdm_rx_hier_usrp_0, '0']
- [epy_block_0, int_cent_freq, analog_sig_source_x_0_0, cmd]
- [epy_block_0, rx_cent_freq, ofdm_rx_hier_usrp_0, cent_freq]
- [epy_block_0, tx_cent_freq, analog_sig_source_x_0, cmd]
- [epy_block_0, tx_cent_freq, ofdm_tx_hier_usrp_0, send_burst]
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0, '0']
- [ofdm_rx_hier_usrp_0, '0', blocks_file_sink_0, '0']
- [ofdm_rx_hier_usrp_0, packet_data, epy_block_0, packet_results]
- [ofdm_tx_hier_usrp_0, '0', mmse_resampler_xx_0, '0']
- [ofdm_tx_hier_usrp_0, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
